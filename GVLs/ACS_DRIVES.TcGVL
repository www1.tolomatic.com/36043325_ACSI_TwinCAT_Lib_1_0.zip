{attribute 'qualified_only'}
VAR_GLOBAL
	//Global GVL for drives
	ACS_DRIVE_1 	: ACS_DRIVE_TYPE;
END_VAR
